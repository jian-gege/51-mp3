# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STC8A_GPIO.c sd.h Config.h STC8A_GPIO.h sd.c STC8A_NVIC.c STC8A_SPI.c STC8A_SPI_Isr.c STC8A_NVIC.h STC8A_SPI.h STC8A_Switch.h STC8A8K64D4.H Type_def.h cc_macro.h deviceio.h gb2uni.h myfun.h template.h ZNFAT.H znFAT.c deviceio.c 1003b.c 1003b.h oled.c bmp.h oled.h oledfont.h EEPROM.c EEPROM.h
